RRECOMMENDS_packagegroup-core-tools-profile_append_lanner-nca1010 = "systemtap"
